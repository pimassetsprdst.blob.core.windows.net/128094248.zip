Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2022-12-21T16:25:14
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Dec 21 16:25:14 2022 * Host: DSBIRNE-RO-LE * Database: C:\Users\DSbirne\AppData\Local\Temp\e3ff18ec-1589-47a6-92e9-616b39fa2ce7\c643ee64-de03-4f9f-9276-6f28dd267892\ifc * Database version: 5507 * Database creation date: Wed Dec 21 16:25:13 2022 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Wed Dec 21 16:25:13 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Dec 21 16:25:13 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:Floor Level, F00
LongName: F00; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Floor Level
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Pset_BuildingStoreyCommon - Reference: Floor Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: F00; Structural: no
Other - Category: Levels; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level

# IfcDistributionPort (3)
Description: Flow; FlowDirection: SOURCEANDSINK
Name
2 x Port_3721360
Port_3721361

# IfcJunctionBox: H251, E_Wall Junction Box_F_MEPcontent_ABB_H251_NL-NL:H251:3721361
In: F00
Type - Material: Color RGB 050-100-201
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Rotation U-Axis Correction: 0 deg; Rotation V-Axis Correction: 0 deg; Rotation W-Axis Correction: 0 deg; Depth: 52.5 mm
Type - Electrical - App ID: EL_MODELPARTSYSTEM_MC
Type - Identity Data - Custom: no; Article Description: 2-voudige inbouwdoos, 50 mm 1x16/19mm; Article Type: H251; Base Family Version: 22.07; Category: EL_SYMBOL_ARTICLE; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Description: 2-voudige inbouwdoos, 50 mm 1x16/19mm; EMCS Version: 4.0; ETIM Article Class: EC002601; Family Version: 11.14; GLN: 8712507100009; GTIN: 8712507087928; Manufacturer: ABB; Manufacturer Art. No.: 1SPA007120F0197; Manufacturer URL: https://www.abbconnect.nl/artlink.aspx?id=8712507087928&LanguageCode=NL&Country=NL; MEPcontent Class: WALL_JUNCTION_BOX; Model: H251; OmniClass Number: 23.80.30.14.24; OmniClass Title: Junction Boxes; Product Line: ABB; Revit Version: 2020; Type Name: H251; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Model Properties - 3D Representation: 3DGeometry
Type - Other - Category: Electrical Fixtures; Family Name: E_Wall Junction Box_F_MEPcontent_ABB_H251_NL-NL
Type - Pset_EnvironmentalImpactIndicators - Reference: H251
Type - Pset_JunctionBoxTypeCommon - Reference: H251; IsExternal: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: ABB
Constraints - Negative Offset: 10 mm
Dimensions - Rotation U-Axis: 0 deg; Rotation V-Axis: 0 deg; Rotation W-Axis: 0 deg; Area: 0.0404242 m2; Connection Diameter: 16 mm; Volume: 0.0000981415 m3
General - Wall Offset: -52.5 mm
Identity Data - Function Code: E6000; Mark: 6
Other - 16 mm Diameter Fixed Spout: yes; 19 mm Diameter Fixed Spout: no; Family: E_Wall Junction Box_F_MEPcontent_ABB_H251_NL-NL: H251; Family and Type: E_Wall Junction Box_F_MEPcontent_ABB_H251_NL-NL: H251; Type: E_Wall Junction Box_F_MEPcontent_ABB_H251_NL-NL: H251; Type Id: E_Wall Junction Box_F_MEPcontent_ABB_H251_NL-NL: H251
Phasing - Phase Created: 4. Plan over 10 years

# IfcOutlet: 20-2 EUCJ-184K-503, E_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Future linear_2CKA002014A1466_H251_NL-NL:20-2 EUCJ-184K-503:3721360
In: F00
Type - PredefinedType: POWEROUTLET; Material: Color RAL 9016
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 40 mm; Frame Thickness: 7 mm; Gang Height: 64 mm; Gang Width: 64 mm; Height: 81 mm; Rotation U-Axis Correction: 0 deg; Rotation V-Axis Correction: 0 deg; Rotation W-Axis Correction: 0 deg; Rounding Gang: 1 mm; Rounding Radius: 0 mm; Width: 152 mm
Type - Electrical - App ID: EL_MODELPARTSYSTEM; Frame Type: Studiowit; Material: Color RAL 9016; Number of Gangs: 2
Type - Identity Data - Article Code: Default; Article Description: Wandcontactdoos Future linear wcd ra dubbel hor m raam f-studiowit; Article Type: 20-2 EUCJ-184K-503; Base Family Version: 20221128; Category: EL_SYMBOL_ARTICLE; Content Supplier URL: www.MEPcontent.com; Custom: no; Description: Wandcontactdoos Future linear wcd ra dubbel hor m raam f-studiowit; EMCS Version: 4.0; ETIM Article Class: EC000125; Family Version: 22.13; GLN: 8712507900012; GTIN: 4011395103265; Manufacturer: ABB BUSCH-JAEGER; Manufacturer Art. No.: 2CKA002014A1466; Manufacturer Type: 20-2 EUCJ-184K-503; Manufacturer URL: https://www.abbconnect.nl/artlink.aspx?id=4011395103265&LanguageCode=NL&Country=NL; MEPcontent Class: ELECTRICAL_FIXTURES; Model: 20-2 EUCJ-184K-503; OmniClass Number: 23.80.50.11; OmniClass Title: Switches and Receptacles; Product Line: Future linear; Revit Version: 2020; Type Name: 20-2 EUCJ-184K-503; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Model Properties - 3D Representation: 3DGeometry
Type - Other - Category: Data Devices; Family Name: E_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Future linear_2CKA002014A1466_H251_NL-NL
Type - Pset_EnvironmentalImpactIndicators - Reference: 20-2 EUCJ-184K-503
Type - Pset_ManufacturerTypeInformation - Manufacturer: ABB BUSCH-JAEGER
Type - Pset_OutletTypeCommon - Reference: 20-2 EUCJ-184K-503
Pset_EnvironmentalImpactIndicators - sets with these values: 2
Constraints - Annotation Offset: 0 mm; Annotation Offset RL: 0 mm; Elevation from Level: 0 mm
Dimensions - Area: 0.0324742 m2; Connection Diameter: 16 mm; Rotation U-Axis: 0 deg; Rotation V-Axis: 0 deg; Rotation W-Axis: 0 deg; Volume: 0.000121832 m3
Electrical - Circuiting - Electrical Data: Power - Balanced 230 V/1-200 VA
Electrical - Loads - Load Classification: Power; Power: 200 W
Identity Data - Copyright: © Trimble Europe BV; Mark: 2; VERSION: 221200
Other - Family: E_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Future linear_2CKA002014A1466_H251_NL-NL: 20-2 EUCJ-184K-503; Family and Type: E_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Future linear_2CKA002014A1466_H251_NL-NL: 20-2 EUCJ-184K-503; Gang 3: 71 mm; Gang Reference Line: 135 mm; Interior Width: 32 mm; Number of Representation Line: 2; Type: E_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Future linear_2CKA002014A1466_H251_NL-NL: 20-2 EUCJ-184K-503; Type Id: E_Socket_F_MEPcontent_SWiRAC_ABB BUSCH-JAEGER_Future linear_2CKA002014A1466_H251_NL-NL: 20-2 EUCJ-184K-503
Phasing - Phase Created: 4. Plan over 10 years
Visibility - 16 mm Diameter Fixed Spout: yes; 19 mm Diameter Fixed Spout: no
